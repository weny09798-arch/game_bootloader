# Keil uVision project GameOTA.uvprojx, settings and files
target boot (6070000::V6.7::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: boot +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,VECT_TAB_OFFSET=0,OTA_BOOTLOADER
  c misc: --diag_suppress=1,1295
  c include: .\firmware\common;.\firmware\port;.\firmware\app;.\firmware\legacy\Start;.\firmware\legacy\User;.\firmware\legacy\Library;.\firmware\legacy\Inc
  memory RVCT4: ROM 0x08000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Firmware
    ./firmware/common/: ota.c protocol.c
    ./firmware/port/: board.c debounce.c jump.s
    ./firmware/legacy/Start/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
    ./firmware/legacy/Library/: misc.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c
    ./firmware/legacy/Src/: OLED_I2C.c OLED_Data.c generic.c
    ./firmware/boot/: main.c
    ./firmware/app/: game.c app_support.c characters.c
target deer (6070000::V6.7::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08004000,0x5c00) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: deer +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,VECT_TAB_OFFSET=0x4000,OTA_APPLICATION,GAME_VERSION=1
  c misc: --diag_suppress=1,1295
  c include: as above
  memory RVCT4: ROM 0x08004000 size 0x5c00
  memory RVCT9: RAM 0x20000000 size 0x5000
target dinosaur (6070000::V6.7::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: dinosaur +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,VECT_TAB_OFFSET=0x4000,OTA_APPLICATION,GAME_VERSION=2
  c misc: --diag_suppress=1,1295
  c include: as above
  memory RVCT4: ROM 0x08004000 size 0x5c00
  memory RVCT9: RAM 0x20000000 size 0x5000
